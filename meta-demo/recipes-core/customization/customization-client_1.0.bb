# This software is a part of isar demo.
# Copyright (c) Siemens AG, 2026
#
# SPDX-License-Identifier: MIT

## Client customization with static IP

require customization.inc

ISAR_DEMO_HOSTNAME = "isar-demo-client"
ISAR_DEMO_ETHERNET_IPV4 = "10.0.5.10/24"
