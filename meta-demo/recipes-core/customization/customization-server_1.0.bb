# This software is a part of isar demo.
# Copyright (c) Siemens AG, 2026
#
# SPDX-License-Identifier: MIT

## Control-plane customization with static IP

require customization.inc

ISAR_DEMO_HOSTNAME = "isar-demo-server"
ISAR_DEMO_ETHERNET_IPV4 = "10.0.5.1/24"
